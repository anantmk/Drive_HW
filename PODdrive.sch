File: PODdrive.sch (KiCad schematic (older format))
At the start: 63 parts

Commit message: test
Parts:
- gave numbers to parts that had none: 63
